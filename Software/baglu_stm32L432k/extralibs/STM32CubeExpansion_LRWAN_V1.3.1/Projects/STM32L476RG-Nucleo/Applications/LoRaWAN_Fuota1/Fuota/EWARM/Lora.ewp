# IAR project Lora.ewp, settings and files
configuration sx1276mb1mas (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER; REGION_EU868; ACTIVE_REGION=LORAMAC_REGION_EU868
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Drivers/BSP/sx1276mb1mas; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler/packages; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region; ../../Linker_Common/EWARM; ../../2_Images_SECoreBin/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\UserApp.bin
  postbuild: cmd /C "cmd /C ..\..\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "UserApp.bin" 1"
  ILINK.IlinkOutputFile: sx1276mb1mas.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sx1272mb2das (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L476RE ST STM32L476RE
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx1272; ../../../../../../Drivers/BSP/sx1272mb2das; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler/packages; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region; ../../Linker_Common/EWARM; ../../2_Images_SECoreBin/Inc
  ILINK.IlinkOutputFile: sx1272mb2das.out
configuration sx1276mb1las (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Drivers/BSP/sx1276mb1las; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler/packages; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region; ../../Linker_Common/EWARM; ../../2_Images_SECoreBin/Inc
  ILINK.IlinkOutputFile: sx1276mb1las.out
configuration sx1261dvk1bas (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER; REGION_EU868; USE_SX126X_DVK; ACTIVE_REGION=LORAMAC_REGION_EU868
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx126x; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler/packages; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region; ../../Linker_Common/EWARM; ../../2_Images_SECoreBin/Inc
configuration sx1262dvk1cas (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
configuration sx1262dvk1das (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/sx126x/: radio.c sx126x.c
    ../../../../../../Drivers/BSP/Components/sx1272/: sx1272.c
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/LRWAN_NS1
    ../../../../../../Drivers/BSP/LRWAN_NS1/: lrwan_ns1.c lrwan_ns1_humidity.c lrwan_ns1_pressure.c lrwan_ns1_temperature.c sx1276_lrwan_ns1.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/sx1261dvk1bas
    ../../../../../../Drivers/BSP/SX1261DVK1BAS/: sx1261dvk1bas.c
  group Drivers/BSP/sx1262dvk1cas
    ../../../../../../Drivers/BSP/SX1262DVK1CAS/: sx1262dvk1cas.c
  group Drivers/BSP/sx1262dvk1das
    ../../../../../../Drivers/BSP/SX1262DVK1DAS/: sx1262dvk1das.c
  group Drivers/BSP/sx1272mb2das
    ../../../../../../Drivers/BSP/SX1272MB2DAS/: sx1272mb2das.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../Drivers/BSP/SX1276MB1LAS/: sx1276mb1las.c
  group Drivers/BSP/sx1276mb1mas
    ../../../../../../Drivers/BSP/SX1276MB1MAS/: sx1276mb1mas.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../Core/src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c
  group Middlewares/LoRaWAN/Crypto
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
  group Middlewares/LoRaWAN/Mac
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
  group Middlewares/LoRaWAN/Mac/Region
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group Middlewares/LoRaWAN/Patterns/Advanced
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler/packages/: FragDecoder.c LmhpClockSync.c LmhpCompliance.c LmhpFragmentation.c LmhpRemoteMcastSetup.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/LmHandler/: LmHandler.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Advanced/: NvmCtxMgmt.c
  group Middlewares/LoRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c queue.c systime.c timeServer.c trace.c utilities.c
  group Projects/End_Node_Fuota
    ../LoRaWAN/App/src/: bsp.c debug.c FlashMemHandler.c FwUpdateAgent.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c
    ../Core/src/: stm32l4xx_hal_msp.c stm32l4xx_hw.c stm32l4xx_it.c
  group Projects/EWARM
    ./: startup_stm32l476xx.s
