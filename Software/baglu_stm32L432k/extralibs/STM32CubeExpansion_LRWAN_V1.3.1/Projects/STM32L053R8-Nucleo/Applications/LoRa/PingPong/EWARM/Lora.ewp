# IAR project Lora.ewp, settings and files
configuration sx1276mb1mas (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; REGION_EU868; USE_MODEM_LORA
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/BSP/STM32L0xx_Nucleo; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Drivers/BSP/sx1276mb1mas
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lora.bin
  ILINK.IlinkOutputFile: sx1276mb1mas.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sx1272mb2das (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/BSP/STM32L0xx_Nucleo; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx1272; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Drivers/BSP/sx1272mb2das
  ILINK.IlinkOutputFile: sx1272mb2das.out
configuration sx1276mb1las (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/BSP/STM32L0xx_Nucleo; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic; ../../../../../../Drivers/BSP/sx1276mb1las
  ILINK.IlinkOutputFile: sx1276mb1las.out
configuration sx1261dvk1bas (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; REGION_EU868; USE_MODEM_LORA; USE_SX126X_DVK
  ICCARM.CCIncludePath2: ../Core/inc; ../LoRaWAN/App/inc; ../../../../../../Drivers/BSP/STM32L0xx_Nucleo; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto; ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac; ../../../../../../Middlewares/Third_Party/LoRaWAN/Phy; ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/sx126x; ../../../../../../Middlewares/Third_Party/LoRaWAN/Patterns/Basic
configuration sx1262dvk1cas (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
configuration sx1262dvk1das (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/sx126x/: radio.c sx126x.c
    ../../../../../../Drivers/BSP/Components/sx1272/: sx1272.c
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/LRWAN_NS1
    ../../../../../../Drivers/BSP/LRWAN_NS1/: sx1276_lrwan_ns1.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/sx1261dvk1bas
    ../../../../../../Drivers/BSP/SX1261DVK1BAS/: sx1261dvk1bas.c
  group Drivers/BSP/sx1262dvk1cas
    ../../../../../../Drivers/BSP/SX1262DVK1CAS/: sx1262dvk1cas.c
  group Drivers/BSP/sx1262dvk1das
    ../../../../../../Drivers/BSP/SX1262DVK1DAS/: sx1262dvk1das.c
  group Drivers/BSP/sx1272mb2das
    ../../../../../../Drivers/BSP/SX1272MB2DAS/: sx1272mb2das.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../Drivers/BSP/SX1276MB1LAS/: sx1276mb1las.c
  group Drivers/BSP/sx1276mb1mas
    ../../../../../../Drivers/BSP/SX1276MB1MAS/: sx1276mb1mas.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/LoRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c queue.c timeServer.c trace.c utilities.c
  group Projects/EWARM
    ./: startup_stm32l053xx.s
  group Projects/PingPong
    ../LoRaWAN/App/src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c
    ../Core/src/: stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c
